Commit message: make gel deformable

File: meshes/digit.urdf (robot description, URDF)
Before this commit: robot digit, 1 links, 0 joints
Links:
- link baseLink: geometry collision mesh filename=digit_no_gel.stl scale=1 1 1; visual mesh filename=digit_no_gel.stl scale=1 1 1
